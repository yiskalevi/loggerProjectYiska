## package/my_server/Config.in
```kconfig
config BR2_PACKAGE_MY_SERVER
    bool "my_server"
    help
        UDP server package.

        
```
